# Repository tuton-RCJ/2025PCB

## KiCad design 01-main/01-main.kicad_pcb

Board: 2 copper layers, 104.0 x 95.0 mm, 66 parts (0 on the bottom side), 58 nets.

Parts:
BZ1: Buzzer; Buzzer_TDK_PS1240P02BT_D12.2mm_H6.5mm
C1, C3, C4, C5, C6, C8, C9, C11, C12, C13: 100n; C_0402_1005Metric
C2, C7: 4.7u; C_0402_1005Metric
C10: 1u; C_0402_1005Metric
D1: LED_ORANGE; LED_1206_3216Metric
D2: LED_GREEN; LED_1206_3216Metric
FB1: FerriteBead; R_0805_2012Metric
J1: ToLINE; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J2: ToTop; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: ToFront; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J4: 5V IN; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J5: 3V3 IN; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J7: LOADCELL_R; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J8: LOADCELL_L; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J9: arm1; PinHeader_1x03_P2.54mm_Vertical
J10: arm2; PinHeader_1x03_P2.54mm_Vertical
J11: handL; PinHeader_1x03_P2.54mm_Vertical
J12: handR; PinHeader_1x03_P2.54mm_Vertical
J13: back; PinHeader_1x03_P2.54mm_Vertical
J22: USB_C_Receptacle_USB2.0; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
Q1: 2SA1015; TO-92_Inline
R1, R2, R15, R16, R17, R18: 10k; R_0603_1608Metric
R3: 7.5k; R_0603_1608Metric
R4, R5, R6, R7: 330; R_0603_1608Metric
R8: 20k; R_0603_1608Metric
R9, R10, R11, R12: 330k; R_0603_1608Metric
R13, R14: 2.2k; R_0603_1608Metric
R19, R21: 75; R_0805_2012Metric
R20, R22: 5.1k; R_0805_2012Metric
SW1: BOOT0; SW_PUSH_6mm
SW2: NRST; SW_PUSH_6mm
U1: BNO055
U2, U4, U5, U7: vl53l0x_vertical
U3: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U6: XIAO_Board
U8: CH340E; MSOP-10_3x3mm_P0.5mm
U12: MAX485ESA; SOP-8_3.9x4.9mm_P1.27mm
U13: MPU6050
U14: LM358; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C3.2, C4.2, C5.2, C6.2, C7.1, C8.2, FB1.1, J3.1, J5.1, J7.4, J8.4, R15.2, R16.1, R17.2, R18.1, SW1.1, U1.1 (VIN), U2.1 (3V3), U3.1 (VBAT), U3.19 (VDD), U3.32 (VDD), U3.48 (VDD), U3.64 (VDD), U4.1 (3V3), U5.1 (3V3), U7.1 (3V3), U13.1 (VCC), U14.8 (V+)
+5V: C11.1, C13.1, J2.1, J4.1, J9.2, J10.2, J11.2, J12.2, J13.2, Q1.2 (C), R13.1, U6.14 (5V), U8.7 (VCC), U12.8 (VCC)
BAT: J1.4, U3.62 (PB9)
BOOT0: R1.1, SW1.2, U3.60 (BOOT0)
D+: J22.A6 (D+), J22.B6 (D+), U8.1 (UD+)
D-: J22.A7 (D-), J22.B7 (D-), U8.2 (UD-)
GND: BZ1.2 (+), C1.1, C2.2, C3.1, C4.1, C5.1, C6.1, C7.2, C8.1, C9.1, C10.1, C11.2, C12.1, C13.2, J2.4, J3.4, J4.2, J5.2, J7.1, J8.1, J9.3, J10.3, J11.3, J12.3, J13.3, J22.A1 (GND), J22.A12 (GND), J22.B1 (GND), J22.B12 (GND), R1.2, R2.2, R8.2, R9.2, R11.2, R14.1, R19.2, R20.1, R21.2, R22.1, SW2.1, U1.2 (GND), U2.2 (GND), U3.12 (VSSA), U3.18 (VSS), U3.31 (VSS), U3.47 (VSS), U3.63 (VSS), U4.2 (GND), U5.2 (GND), U6.13 (GND), U7.2 (GND), U8.3 (GND), U12.5 (GND), U13.2 (GND), U14.4 (V-)
I2C1_SCL: R15.1, U1.4 (SCL), U2.3 (SCL), U3.58 (PB6), U4.3 (SCL), U5.3 (SCL), U7.3 (SCL)
I2C1_SDA: R16.2, U1.3 (SDA), U2.4 (SDA), U3.59 (PB7), U4.4 (SDA), U5.4 (SDA), U7.4 (SDA)
I2C2_SCL: R17.1, U3.29 (PB10), U13.3 (SCL)
I2C2_SDA: R18.2, U3.55 (PB3), U13.4 (SDA)
LOADCEL_L: R12.1, U3.9 (PC1), U14.1
LOADCEL_R: R10.1, U3.8 (PC0), U14.7
NRST: C1.2, SW2.2, U3.7 (NRST)
unnamed: D1.2 (A), U8.6 (TNOW)
unnamed: D1.1 (K), R19.1
unnamed: D2.2 (A), J22.A4 (VBUS), J22.A9 (VBUS), J22.B4 (VBUS), J22.B9 (VBUS)
unnamed: D2.1 (K), R21.1
unnamed: J7.2, R4.1
unnamed: J7.3, R5.2
unnamed: J8.2, R6.1
unnamed: J8.3, R7.2
unnamed: J22.A5 (CC1), R22.2
unnamed: J22.B5 (CC2), R20.2
unnamed: Q1.3 (B), R3.1
unnamed: Q1.1 (E), R8.1, U12.2 (~RE), U12.3 (DE)
unnamed: R2.1, U3.28 (PB2)
unnamed: C2.1, U3.30 (VCAP_1)
unnamed: C9.2, C10.2, FB1.2, U3.13 (VDDA)
unnamed: C12.2, U8.10 (V3)
unnamed: R13.2, R14.2, U12.7 (B)
unnamed: R6.2, R11.1, U14.3 (+)
unnamed: R7.1, R12.2, U14.2 (-)
unnamed: R4.2, R9.1, U14.5 (+)
unnamed: R5.1, R10.2, U14.6 (-)
STS_SIG: J1.3, U12.6 (A)
UART1_RX: U3.43 (PA10), U8.8 (TXD)
UART1_TX: U3.42 (PA9), U8.9 (RXD)
UART2_RX: J1.1, U3.17 (PA3)
UART2_TX: J1.2, U3.16 (PA2)
UART3_RX: U3.25 (PC5), U12.1 (RO)
UART3_TX: R3.2, U3.51 (PC10), U12.4 (DI)
UART4_RX: J3.2, U3.15 (PA1)
UART4_TX: J3.3, U3.14 (PA0)
UART5_RX: J2.2, U3.54 (PD2)
UART5_TX: J2.3, U3.53 (PC12)
UART6_RX: U3.38 (PC7), U6.7 (D6)
UART6_TX: U3.37 (PC6), U6.8 (D7)
XSHUT1: U2.5 (XSHUT), U3.45 (PA12)
XSHUT2: U3.46 (PA13), U4.5 (XSHUT)
XSHUT3: U3.49 (PA14), U5.5 (XSHUT)
XSHUT4: U3.50 (PA15), U7.5 (XSHUT)
buzzer: BZ1.1 (-), U3.27 (PB1)
servo1: J9.1, U3.41 (PA8)
servo2: J10.1, U3.44 (PA11)
servo3: J11.1, U3.21 (PA5)
servo4: J12.1, U3.22 (PA6)
servo5: J13.1, U3.23 (PA7)

## KiCad design 02-top/02-top.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
J1: ToTop; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J2: SSD1306; PinHeader_1x04_P2.54mm_Vertical
R1, R2, R3, R4: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1, SW2, SW3: SW_Push; SW_PUSH-12mm
SW4: SW_SPDT; PinHeader_1x03_P2.54mm_Vertical
U1: XIAO_Board

Connections:
+3V3: J2.2, R1.1, R2.1, R3.1, R4.1, U1.12 (3V3)
+5V: D1.1 (VDD), D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), J1.1, U1.14 (5V)
GND: D1.3 (VSS), D2.3 (VSS), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), J1.4, J2.1, SW1.2, SW2.2, SW3.2, SW4.1 (A), U1.13 (GND)
I2C_SCL: J2.3, U1.6 (D5)
I2C_SDA: J2.4, U1.5 (D4)
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D2.2 (DOUT), D3.4 (DIN)
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
SW: R4.2, SW4.2 (B), U1.3 (D2)
SW1: R1.2, SW1.1, U1.11 (D10)
SW2: R2.2, SW2.1, U1.10 (D9)
SW3: R3.2, SW3.1, U1.9 (D8)
UART5_RX: J1.2, U1.7 (D6)
UART5_TX: J1.3, U1.8 (D7)
WS2812B: D1.4 (DIN), U1.4 (D3)

Notes on the sheet:
ESPじゃなくてRP2040です

Board: 2 copper layers, 19 parts (5 on the bottom side), 19 nets, no tracks yet.

## KiCad design 03-front/03-front.kicad_pcb

Board: 2 copper layers, 110.0 x 60.0 mm, 36 parts (17 on the bottom side), 33 nets.

Parts:
C1, C3, C4, C5, C6, C8, C9: 100n; C_0402_1005Metric
C2, C7: 4.7u; C_0402_1005Metric
C10: 1u; C_0402_1005Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
FB1: FerriteBead; R_0805_2012Metric
J1: WRITER CONN; PinSocket_2x04_P2.54mm_Vertical
J2: ToMAIN; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
R1, R2, R3, R4: 10k; R_0603_1608Metric
U1: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U2, U3, U4, U5, U6: VL53L0X_horizontal
U7: OpenMV h7

Connections:
+3V3: C3.2, C4.2, C5.2, C6.2, C7.1, C8.2, FB1.1, J1.8, R3.1, R4.2, U1.1 (VBAT), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U2.1 (3V3), U3.1 (3V3), U4.1 (3V3), U5.1 (3V3), U6.1 (3V3), U7.8 (3V3)
+5V: D1.1 (VDD), D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), D10.1 (VDD), D11.1 (VDD), D12.1 (VDD), J2.1, U7.15 (VIN)
BOOT0: J1.5, R1.1, U1.60 (BOOT0)
GND: C1.1, C2.2, C3.1, C4.1, C5.1, C6.1, C7.2, C8.1, C9.1, C10.1, D1.3 (VSS), D2.3 (VSS), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), D10.3 (VSS), D11.3 (VSS), D12.3 (VSS), J1.6, J2.4, R1.2, R2.2, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U2.2 (GND), U3.2 (GND), U4.2 (GND), U5.2 (GND), U6.2 (GND), U7.16 (GND)
I2C1_SCL: R4.1, U1.58 (PB6), U2.3 (SCL), U3.3 (SCL), U4.3 (SCL), U5.3 (SCL), U6.3 (SCL)
I2C1_SDA: R3.2, U1.59 (PB7), U2.4 (SDA), U3.4 (SDA), U4.4 (SDA), U5.4 (SDA), U6.4 (SDA)
NRST: C1.2, J1.3, U1.7 (NRST)
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D2.2 (DOUT), D3.4 (DIN)
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: D8.2 (DOUT), D9.4 (DIN)
unnamed: D9.2 (DOUT), D10.4 (DIN)
unnamed: D10.2 (DOUT), D11.4 (DIN)
unnamed: D11.2 (DOUT), D12.4 (DIN)
unnamed: R2.1, U1.28 (PB2)
unnamed: C2.1, U1.30 (VCAP_1)
unnamed: C9.2, C10.2, FB1.2, U1.13 (VDDA)
UART1_RX: J1.2, U1.43 (PA10)
UART1_TX: J1.4, U1.42 (PA9)
UART2_RX: J2.3, U1.17 (PA3)
UART2_TX: J2.2, U1.16 (PA2)
UART3_RX: U1.25 (PC5), U7.2 (P1)
UART3_TX: U1.51 (PC10), U7.1 (P0)
WS2812B: D1.4 (DIN), U1.44 (PA11)
XSHUT1: U1.20 (PA4), U2.5 (XSHUT)
XSHUT2: U1.21 (PA5), U3.5 (XSHUT)
XSHUT3: U1.22 (PA6), U4.5 (XSHUT)
XSHUT4: U1.23 (PA7), U5.5 (XSHUT)
XSHUT5: U1.41 (PA8), U6.5 (XSHUT)

File 03-front/jlcpcb/production_files/BOM-03-front.csv:

Comment,Designator,Footprint,LCSC
FerriteBead,FB1,R_0805_2012Metric,C1015
100n,"C1,C3,C4,C5,C6,C8,C9",C_0402_1005Metric,C1525
4.7u,"C2,C7",C_0402_1005Metric,C23733
10k,"R1,R2,R3,R4",R_0603_1608Metric,C25804
1u,C10,C_0402_1005Metric,C52923
STM32F446RETx,U1,LQFP-64_10x10mm_P0.5mm,C69336
WS2812B,D1,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
~,U4,VL53L0X_horizontal,
~,U3,VL53L0X_horizontal,
~,U6,VL53L0X_horizontal,
~,U2,VL53L0X_horizontal,
~,U5,VL53L0X_horizontal,
~,U7,OpenMV h7,
WS2812B,D9,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
WS2812B,D6,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
WS2812B,D3,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
WS2812B,D12,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
WS2812B,D2,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
WS2812B,D8,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
WS2812B,D4,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
WS2812B,D10,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
WS2812B,D5,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
WS2812B,D7,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
WS2812B,D11,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
ToMAIN,J2,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,
WRITER CONN,J1,PinSocket_2x04_P2.54mm_Vertical,

## KiCad design 04-line/04-line.kicad_pcb

Board: 2 copper layers, 80.0 x 52.0 mm, 61 parts (3 on the bottom side), 46 nets.

Parts:
C3, C6: 100n; C_0402_1005Metric
D1, D2, D4, D5, D6, D8: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
J1: Conn_01x18; PinHeader_1x18_P2.54mm_Vertical
J2: CS_R; PinHeader_2x03_P2.54mm_Vertical
J3: CS_L; PinHeader_2x03_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R19, R20, R21, R22, R23, R24, R25: 120; R_0603_1608Metric
R10, R11, R12, R13, R14, R15, R16, R17, R18, R28, R29, R30, R31, R32, R33, R34: 1k; R_0603_1608Metric
U2, U3, U4, U5, U6, U7, U8, U9, U10, U12, U13, U14, U15, U16, U17, U18: LBR127HLD
U25, U26: S11059

Connections:
5V_LED: D1.1 (VDD), D2.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D8.1 (VDD), J2.2, J3.2
+3V3: J1.18, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R28.1, R29.1, R30.1, R31.1, R32.1, R33.1, R34.1, U2.1 (Anode), U3.1 (Anode), U4.1 (Anode), U5.1 (Anode), U6.1 (Anode), U7.1 (Anode), U8.1 (Anode), U9.1 (Anode), U10.1 (Anode), U12.1 (Anode), U13.1 (Anode), U14.1 (Anode), U15.1 (Anode), U16.1 (Anode), U17.1 (Anode), U18.1 (Anode)
GND: C3.2, C6.2, D1.3 (VSS), D2.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D8.3 (VSS), J1.1, J2.4, J3.4, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, U2.3 (Emitter), U3.3 (Emitter), U4.3 (Emitter), U5.3 (Emitter), U6.3 (Emitter), U7.3 (Emitter), U8.3 (Emitter), U9.3 (Emitter), U10.3 (Emitter), U12.3 (Emitter), U13.3 (Emitter), U14.3 (Emitter), U15.3 (Emitter), U16.3 (Emitter), U17.3 (Emitter), U18.3 (Emitter), U25.2 (GND), U25.3 (GND), U25.4 (GND), U25.5 (GND), U25.7 (GND), U25.8 (GND), U25.9 (GND), U26.2 (GND), U26.3 (GND), U26.4 (GND), U26.5 (GND), U26.7 (GND), U26.8 (GND), U26.9 (GND)
I2C1_SCL: J2.5, U26.6 (SCL)
I2C1_SDA: J2.6, U26.10 (SDA)
I2C2_SCL: J3.5, U25.6 (SCL)
I2C2_SDA: J3.6, U25.10 (SDA)
LED_L: D1.4 (DIN), J3.3
LED_R: D5.4 (DIN), J2.3
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D2.2 (DOUT), D4.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D8.4 (DIN)
unnamed: R1.1, U2.2 (Cathode)
unnamed: R2.1, U3.2 (Cathode)
unnamed: R3.1, U4.2 (Cathode)
unnamed: R4.1, U5.2 (Cathode)
unnamed: R5.1, U6.2 (Cathode)
unnamed: R6.1, U7.2 (Cathode)
unnamed: R7.1, U8.2 (Cathode)
unnamed: R8.1, U9.2 (Cathode)
unnamed: R9.1, U10.2 (Cathode)
unnamed: R19.1, U12.2 (Cathode)
unnamed: R20.1, U13.2 (Cathode)
unnamed: R21.1, U14.2 (Cathode)
unnamed: R22.1, U15.2 (Cathode)
unnamed: R23.1, U16.2 (Cathode)
unnamed: R24.1, U17.2 (Cathode)
unnamed: R25.1, U18.2 (Cathode)
SENSER_3V3: C3.1, C6.1, J2.1, J3.1, U25.1 (VDD), U26.1 (VDD)
photo_L_1: J1.8, R10.2, U2.4 (Collector)
photo_L_2: J1.7, R11.2, U3.4 (Collector)
photo_L_3: J1.6, R12.2, U4.4 (Collector)
photo_L_4: J1.5, R13.2, U5.4 (Collector)
photo_L_5: J1.4, R14.2, U6.4 (Collector)
photo_L_6: J1.3, R15.2, U7.4 (Collector)
photo_L_7: J1.2, R16.2, U8.4 (Collector)
photo_R_1: J1.11, R28.2, U12.4 (Collector)
photo_R_2: J1.12, R29.2, U13.4 (Collector)
photo_R_3: J1.13, R30.2, U14.4 (Collector)
photo_R_4: J1.14, R31.2, U15.4 (Collector)
photo_R_5: J1.15, R32.2, U16.4 (Collector)
photo_R_6: J1.16, R33.2, U17.4 (Collector)
photo_R_7: J1.17, R34.2, U18.4 (Collector)
photo_center: J1.9, R17.2, U9.4 (Collector)
photo_front: J1.10, R18.2, U10.4 (Collector)

## KiCad design 04-line_sub/04-line_sub.kicad_pcb

Parts:
C1, C3, C4, C5, C6, C8, C9: 100n; C_0402_1005Metric; LCSC C1525
C2, C7: 4.7u; C_0402_1005Metric; LCSC C23733
C10: 1u; C_0603_1608Metric; LCSC C15849
D1: LED_GREEN; LED_0805_2012Metric; LCSC C2297
FB1: FerriteBead; R_0805_2012Metric; LCSC C1015
J1: Conn_01x06; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J2: WRITER CONN; PinHeader_2x04_P2.54mm_Vertical
J3: CS_R; PinHeader_2x03_P2.54mm_Vertical
J4: Conn_01x18; PinHeader_1x18_P2.54mm_Vertical
J5: CS_L; PinHeader_2x03_P2.54mm_Vertical
R1, R2, R4, R5, R6, R7: 10k; R_0805_2012Metric; LCSC C17414
R3: 470; R_0603_1608Metric; LCSC C23179
U1: STM32F446RETx; LQFP-64_10x10mm_P0.5mm; LCSC C69336

Connections:
3V3_LED: J1.2, J4.1
5V_LED: J1.1, J3.2, J5.2
+3V3: C3.2, C4.2, C5.2, C6.2, C7.1, C8.2, D1.2 (A), FB1.1, J1.3, J2.2, J3.1, J5.1, R4.2, R5.2, R6.2, R7.2, U1.1 (VBAT), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD)
BOOT0: J2.3, R1.1, U1.60 (BOOT0)
GND: C1.1, C2.2, C3.1, C4.1, C5.1, C6.1, C7.2, C8.1, C9.1, C10.1, J1.4, J2.4, J3.4, J4.18, J5.4, R1.2, R2.2, R3.1, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS)
I2C1_SCL: J3.5, R4.1, U1.58 (PB6)
I2C1_SDA: J3.6, R5.1, U1.59 (PB7)
I2C2_SCL: J5.5, R6.1, U1.29 (PB10)
I2C2_SDA: J5.6, R7.1, U1.53 (PC12)
I2C3_SCL: U1.41 (PA8)
I2C3_SDA: U1.40 (PC9)
LED_L: J5.3, U1.4 (PC15)
LED_R: J3.3, U1.3 (PC14)
NRST: C1.2, J2.5, U1.7 (NRST)
unnamed: D1.1 (K), R3.2
unnamed: R2.1, U1.28 (PB2)
unnamed: C2.1, U1.30 (VCAP_1)
unnamed: C9.2, C10.2, FB1.2, U1.13 (VDDA)
SWCLK: U1.49 (PA14)
SWDIO: U1.46 (PA13)
UART1_RX: J2.8, U1.43 (PA10)
UART1_TX: J2.6, U1.42 (PA9)
UART3_RX: J1.5, U1.52 (PC11)
UART3_TX: J1.6, U1.51 (PC10)
photo_L_1: J4.8, U1.16 (PA2)
photo_L_2: J4.7, U1.15 (PA1)
photo_L_3: J4.6, U1.14 (PA0)
photo_L_4: J4.5, U1.11 (PC3)
photo_L_5: J4.4, U1.10 (PC2)
photo_L_6: J4.3, U1.9 (PC1)
photo_L_7: J4.2, U1.8 (PC0)
photo_R_1: J4.11, U1.21 (PA5)
photo_R_2: J4.12, U1.22 (PA6)
photo_R_3: J4.13, U1.23 (PA7)
photo_R_4: J4.14, U1.24 (PC4)
photo_R_5: J4.15, U1.25 (PC5)
photo_R_6: J4.16, U1.26 (PB0)
photo_R_7: J4.17, U1.27 (PB1)
photo_center: J4.10, U1.20 (PA4)
photo_front: J4.9, U1.17 (PA3)

Board: 2 copper layers, 71.1 x 35.6 mm, 25 parts (0 on the bottom side), 36 nets.

File 04-line_sub/jlcpcb/production_files/BOM-04-line_sub.csv:

Comment,Designator,Footprint,LCSC
FerriteBead,FB1,R_0805_2012Metric,C1015
100n,"C1,C3,C4,C5,C6,C8,C9",C_0402_1005Metric,C1525
1u,C10,C_0603_1608Metric,C15849
10k,"R1,R2,R4,R5,R6,R7",R_0805_2012Metric,C17414
LED_GREEN,D1,LED_0805_2012Metric,C2297
470,R3,R_0603_1608Metric,C23179
4.7u,"C2,C7",C_0402_1005Metric,C23733
STM32F446RETx,U1,LQFP-64_10x10mm_P0.5mm,C69336
Conn_01x18,J4,PinHeader_1x18_P2.54mm_Vertical,
CS_R,J3,PinHeader_2x03_P2.54mm_Vertical,
Conn_01x06,J1,JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical,
WRITER CONN,J2,PinHeader_2x04_P2.54mm_Vertical,
CS_L,J5,PinHeader_2x03_P2.54mm_Vertical,

## KiCad design 05-PWR/05-PWR.kicad_pcb

Board: 2 copper layers, 110.0 x 125.0 mm, 37 parts (0 on the bottom side), 22 nets.

Parts:
C1, C3: 22uF; C_0805_2012Metric
C2, C4: 10uF; C_0805_2012Metric
C5, C6: 1u; C_0805_2012Metric
F1: Fuse; FUSE_3557-15
J1: Battery; SolderWire-2sqmm_1x02_P7.8mm_D2mm_OD3.9mm
J2: VOLTMETER; SolderWire-0.5sqmm_1x02_P4.6mm_D0.9mm_OD2.1mm
J3, J4, J5, J6: STS3032; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J7: ToLINE; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J9: 3V3 ToMAIN; SolderWire-2sqmm_1x02_P7.8mm_D2mm_OD3.9mm
J10: 5V ToMAIN; SolderWire-2sqmm_1x02_P7.8mm_D2mm_OD3.9mm
J11: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
Q1: Q_PMOS_GDS; TO-251-3_Vertical
R1: 1k; R_0603_1608Metric
R2: 330; R_0603_1608Metric
R3: 10; R_0603_1608Metric
R4, R8: 1.2k; R_0603_1608Metric
R5: 1.5k; R_0603_1608Metric
R6: 680; R_0603_1608Metric
R7, R9: 10k; R_0603_1608Metric
RV1, RV2, RV3: R_Trim; Potentiometer_Bourns_3296W_Vertical
SW1: SW_SPST; DS-850K-S-ON
U1, U2: PinHeader_1x05_P2.54mm_Vertical
U3, U4: OKL-T6-W12N-C
U5: M51957B
U6: XC6206P332MR-G; SOT-23-3

Connections:
3V3_LED: C4.1, J7.5, J9.1, R8.1, U4.4 (Vout), U4.5 (Sense)
+3V3: C6.1, J7.4, U6.3 (OUT)
+5V: C2.1, C5.1, J7.6, J10.1, R4.1, U3.4 (Vout), U3.5 (Sense), U6.1 (IN)
Battery_obs: J11.4, U5.6 (OUT)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.2, J2.2, J3.3, J4.3, J5.3, J6.3, J7.3, J9.2, J10.2, R3.2, R4.2, R6.2, R8.2, RV1.3, RV2.3, RV3.3, SW1.1 (A), U1.3 (GND), U2.3 (GND), U3.1 (ON/OFF), U3.3 (GND), U3.7 (GND), U4.1 (ON/OFF), U4.3 (GND), U4.7 (GND), U5.4 (GND), U5.5 (DLY), U6.2 (GND)
Motor_SIG: J3.1, J4.1, J5.1, J6.1, J11.3
unnamed: F1.2, J1.1
unnamed: J3.2, J4.2, U1.2 (VOUT)
unnamed: J5.2, J6.2, U2.2 (VOUT)
unnamed: Q1.1 (G), R9.2, SW1.2 (B)
unnamed: F1.1, Q1.3 (S), R9.1
unnamed: R1.2, R2.1
unnamed: R2.2, R3.1
unnamed: R5.2, R6.1
unnamed: RV1.1, RV1.2, U1.5 (Trim)
unnamed: RV2.1, RV2.2, U2.5 (Trim)
unnamed: R1.1, U3.6 (Trim)
unnamed: R5.1, U4.6 (Trim)
unnamed: R7.2, RV3.1, RV3.2, U5.2 (IN)
UART3_RX: J7.2, J11.2
UART3_TX: J7.1, J11.1
VDD: C1.1, C3.1, J2.1, Q1.2 (D), R7.1, U1.1 (VIN), U2.1 (VIN), U3.2 (Vin), U4.2 (Vin), U5.7 (VDD)
