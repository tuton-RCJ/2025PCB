# Repository tuton-RCJ/2025PCB (continued)

## KiCad design 06_WRITER/06_WRITER.kicad_pcb

Parts:
C1, C2: 100n; C_0805_2012Metric; LCSC C38141
D1: LED_GREEN; LED_1206_3216Metric; LCSC C499475
D2: LED_ORANGE; LED_1206_3216Metric; LCSC C2764895
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal; LCSC C19274016
J2: Conn_02x04_Counter_Clockwise; PinHeader_2x04_P2.54mm_Vertical
R1, R2: 5.1k; R_0805_2012Metric; LCSC C2828689
R3, R4: 75; R_0805_2012Metric; LCSC C441974
SW1: NRST; SW_PUSH_6mm
SW2: BOOT0; SW_PUSH_6mm
U1: CH340E; MSOP-10_3x3mm_P0.5mm; LCSC C99652

Connections:
+3V3: J2.8, SW2.1
+5V: C1.1, D1.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U1.7 (VCC)
BOOT0: J2.5, SW2.2
D+: J1.A6 (D+), J1.B6 (D+), U1.1 (UD+)
D-: J1.A7 (D-), J1.B7 (D-), U1.2 (UD-)
GND: C1.2, C2.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.6, R1.1, R2.1, R3.2, R4.2, SW1.1, U1.3 (GND)
NRST: J2.3, SW1.2
unnamed: D1.1 (K), R3.1
unnamed: D2.2 (A), U1.6 (TNOW)
unnamed: D2.1 (K), R4.1
unnamed: J1.A5 (CC1), R1.2
unnamed: J1.B5 (CC2), R2.2
unnamed: C2.2, U1.10 (V3)
RX: J2.2, U1.8 (TXD)
TX: J2.4, U1.9 (RXD)

Notes on the sheet:
RX NRST TX BOOT GND 3V3

Board: 2 copper layers, 22.9 x 39.4 mm, 13 parts (0 on the bottom side), 15 nets.

File 06_WRITER/jlcpcb/production_files/BOM-06_WRITER.csv:

Comment,Designator,Footprint,LCSC
USB_C_Receptacle_USB2.0,J1,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,C19274016
LED_ORANGE,D2,LED_1206_3216Metric,C2764895
5.1k,"R1,R2",R_0805_2012Metric,C27834
75,"R3,R4",R_0805_2012Metric,C441974
100n,"C1,C2",C_0805_2012Metric,C49678
LED_GREEN,D1,LED_1206_3216Metric,C499475
CH340E,U1,MSOP-10_3x3mm_P0.5mm,C99652
Conn_02x04_Counter_Clockwise,J2,PinHeader_2x04_P2.54mm_Vertical,
BOOT0,SW2,SW_PUSH_6mm,
NRST,SW1,SW_PUSH_6mm,

## KiCad design 08-REG_mod/08-REG_mod.kicad_pcb

Parts:
C1: 10u; C_0805_2012Metric; LCSC C15850
C2: 0.01u; C_0603_1608Metric; LCSC C57112
C3: 220u; CP_Radial_D6.3mm_P2.50mm
D1: SS34; D_SMA; LCSC C8678
D2: LED_green; LED_0805_2012Metric; LCSC C2297
J1: Conn_01x05; PinHeader_1x05_P2.54mm_Horizontal
L1: 22u; FXL1040-220-M; LCSC C475917
R1: 10k; R_0603_1608Metric; LCSC C25804
R3: 470; R_0603_1608Metric; LCSC C23179
U1: TPS5430DDA; TI_SO-PowerPAD-8_ThermalVias

Connections:
EN: J1.4, U1.5 (EN)
GND: C1.2, C3.2, D1.2 (A), J1.3, U1.6 (GND), U1.9 (GNDPAD); also elsewhere on the board
unnamed: C2.2, D1.1 (K), L1.1, U1.8 (PH)
unnamed 3: D2.1 (K); also elsewhere on the board
unnamed: C2.1, U1.1 (BOOT)
Trim: J1.5, R1.2, U1.4 (VSENSE)
VDD: C1.1, J1.1, U1.7 (VIN)
VOUT: C3.1, D2.2 (A), J1.2, L1.2, R1.1

Notes on the sheet:
入力電圧範囲 10.5~12.6V 出力電圧 7.2V 出力電圧定格 1.5A 動作周波数 500kHz
2.04k

Board: 2 copper layers, 19.7 x 26.7 mm, 10 parts (0 on the bottom side), 8 nets.

Other parts of the board:
R2: 470; R_0603_1608Metric

Their connections:
GND: R2.2; also elsewhere on the board
unnamed 3: R2.1; also elsewhere on the board
