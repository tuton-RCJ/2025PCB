# Repository tuton-RCJ/2025PCB

## KiCad design 09-Bottom/09-Bottom.kicad_pcb

Board: 2 copper layers, 66.0 x 27.9 mm, 5 parts (0 on the bottom side), 7 nets, no tracks yet.

Parts:
J1: 5V PWR; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2: ToLINE; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J3: 3V3 PWR; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J4: Conn_01x02; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J5: Conn_01x05; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical

Connections:
3V3_LED: J2.5, J3.2, J5.3
5V: J1.2, J2.6
Battery_obs: J4.2, J5.5
GND: J1.1, J2.3, J3.1
Motor_SIG: J4.1, J5.4
UART3_RX: J2.2, J5.2
UART3_TX: J2.1, J5.1

## KiCad design 09-ToF_mod/09-ToF_mod.kicad_pcb

Board: 2 copper layers, 10.7 x 13.7 mm, 9 parts (2 on the bottom side), 6 nets.

Parts:
C1: 0.1u; C_0603_1608Metric
C2: 4.7u; C_0603_1608Metric
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Horizontal
J2: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
R1, R4: 10k; R_0603_1608Metric
R2, R3: 1.5k; R_0603_1608Metric
U1: VL53L0X; ST_VL53L0X

Connections:
+3V3: C1.1, C2.1, J1.1, R1.1, R2.1, R3.1, R4.1, U1.1 (AVDDVCSEL), U1.11 (AVDD)
GND: C1.2, C2.2, J1.2, U1.2 (AVSSVCSEL), U1.3 (GND), U1.4 (GND), U1.6 (GND), U1.12 (GND)
GPIO: J2.1, R1.2, U1.7 (GPIO1)
SCL: J1.3, R3.2, U1.10 (SCL)
SDA: J1.4, R2.2, U1.9 (SDA)
XSHUT: J2.2, R4.2, U1.5 (XSHUT)

## KiCad design 1-TOKYO/02-top/02-top.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
J1: ToTop; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J2: SSD1306; PinHeader_1x04_P2.54mm_Vertical
R1, R2, R3, R4: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1, SW2, SW3: SW_Push; SW_PUSH_6mm
SW4: SW_SPDT; PinHeader_1x03_P2.54mm_Vertical
U1: XIAO_Board

Connections:
+3V3: J2.2, R1.1, R2.1, R3.1, R4.1, U1.12 (3V3)
+5V: D1.1 (VDD), D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), J1.1, U1.14 (5V)
GND: D1.3 (VSS), D2.3 (VSS), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), J1.4, J2.1, SW1.2, SW2.2, SW3.2, SW4.1 (A), U1.13 (GND)
I2C_SCL: J2.3, U1.6 (D5)
I2C_SDA: J2.4, U1.5 (D4)
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D2.2 (DOUT), D3.4 (DIN)
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
SW: R4.2, SW4.2 (B), U1.3 (D2)
SW1: R1.2, SW1.1, U1.11 (D10)
SW2: R2.2, SW2.1, U1.10 (D9)
SW3: R3.2, SW3.1, U1.9 (D8)
UART5_RX: J1.2, U1.7 (D6)
UART5_TX: J1.3, U1.8 (D7)
WS2812B: D1.4 (DIN), U1.4 (D3)

Notes on the sheet:
ESPじゃなくてRP2040です

Board: 2 copper layers, 121.0 x 25.0 mm, 17 parts (5 on the bottom side), 17 nets.

File 1-TOKYO/02-top/jlcpcb/production_files/BOM-02-top.csv:

Comment,Designator,Footprint,LCSC
ToTop,J1,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,
SW_Push,SW3,SW_PUSH_6mm,
SW_Push,SW2,SW_PUSH_6mm,
SW_Push,SW1,SW_PUSH_6mm,
WS2812B,D3,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
WS2812B,D4,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
WS2812B,D6,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
SSD1306,J2,PinHeader_1x04_P2.54mm_Vertical,
WS2812B,D2,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
SW_SPDT,SW4,PinHeader_1x03_P2.54mm_Vertical,
WS2812B,D1,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
WS2812B,D5,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
~,U1,XIAO_Board,
10k,R1,R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,
10k,R3,R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,
10k,R2,R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,
10k,R4,R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,

## KiCad design 1-TOKYO/04-line/04-line.kicad_pcb

Board: 2 copper layers, 80.0 x 52.0 mm, 61 parts (3 on the bottom side), 46 nets.

Parts:
C3, C6: 100n; C_0402_1005Metric
D1, D2, D4, D5, D6, D8: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
J1: Conn_01x18; PinHeader_1x18_P2.54mm_Vertical
J2: CS_R; PinHeader_2x03_P2.54mm_Vertical
J3: CS_L; PinHeader_2x03_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R19, R20, R21, R22, R23, R24, R25: 120; R_0603_1608Metric
R10, R11, R12, R13, R14, R15, R16, R17, R18, R28, R29, R30, R31, R32, R33, R34: 1k; R_0603_1608Metric
U2, U3, U4, U5, U6, U7, U8, U9, U10, U12, U13, U14, U15, U16, U17, U18: LBR127HLD
U25, U26: S11059

Connections:
5V_LED: D1.1 (VDD), D2.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D8.1 (VDD), J2.2, J3.2
+3V3: J1.18, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R28.1, R29.1, R30.1, R31.1, R32.1, R33.1, R34.1, U2.1 (Anode), U3.1 (Anode), U4.1 (Anode), U5.1 (Anode), U6.1 (Anode), U7.1 (Anode), U8.1 (Anode), U9.1 (Anode), U10.1 (Anode), U12.1 (Anode), U13.1 (Anode), U14.1 (Anode), U15.1 (Anode), U16.1 (Anode), U17.1 (Anode), U18.1 (Anode)
GND: C3.2, C6.2, D1.3 (VSS), D2.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D8.3 (VSS), J1.1, J2.4, J3.4, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, U2.3 (Emitter), U3.3 (Emitter), U4.3 (Emitter), U5.3 (Emitter), U6.3 (Emitter), U7.3 (Emitter), U8.3 (Emitter), U9.3 (Emitter), U10.3 (Emitter), U12.3 (Emitter), U13.3 (Emitter), U14.3 (Emitter), U15.3 (Emitter), U16.3 (Emitter), U17.3 (Emitter), U18.3 (Emitter), U25.2 (GND), U25.3 (GND), U25.4 (GND), U25.5 (GND), U25.7 (GND), U25.8 (GND), U25.9 (GND), U26.2 (GND), U26.3 (GND), U26.4 (GND), U26.5 (GND), U26.7 (GND), U26.8 (GND), U26.9 (GND)
I2C1_SCL: J2.5, U26.6 (SCL)
I2C1_SDA: J2.6, U26.10 (SDA)
I2C2_SCL: J3.5, U25.6 (SCL)
I2C2_SDA: J3.6, U25.10 (SDA)
LED_L: D1.4 (DIN), J3.3
LED_R: D5.4 (DIN), J2.3
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D2.2 (DOUT), D4.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D8.4 (DIN)
unnamed: R1.1, U2.2 (Cathode)
unnamed: R2.1, U3.2 (Cathode)
unnamed: R3.1, U4.2 (Cathode)
unnamed: R4.1, U5.2 (Cathode)
unnamed: R5.1, U6.2 (Cathode)
unnamed: R6.1, U7.2 (Cathode)
unnamed: R7.1, U8.2 (Cathode)
unnamed: R8.1, U9.2 (Cathode)
unnamed: R9.1, U10.2 (Cathode)
unnamed: R19.1, U12.2 (Cathode)
unnamed: R20.1, U13.2 (Cathode)
unnamed: R21.1, U14.2 (Cathode)
unnamed: R22.1, U15.2 (Cathode)
unnamed: R23.1, U16.2 (Cathode)
unnamed: R24.1, U17.2 (Cathode)
unnamed: R25.1, U18.2 (Cathode)
SENSER_3V3: C3.1, C6.1, J2.1, J3.1, U25.1 (VDD), U26.1 (VDD)
photo_L_1: J1.8, R10.2, U2.4 (Collector)
photo_L_2: J1.7, R11.2, U3.4 (Collector)
photo_L_3: J1.6, R12.2, U4.4 (Collector)
photo_L_4: J1.5, R13.2, U5.4 (Collector)
photo_L_5: J1.4, R14.2, U6.4 (Collector)
photo_L_6: J1.3, R15.2, U7.4 (Collector)
photo_L_7: J1.2, R16.2, U8.4 (Collector)
photo_R_1: J1.11, R28.2, U12.4 (Collector)
photo_R_2: J1.12, R29.2, U13.4 (Collector)
photo_R_3: J1.13, R30.2, U14.4 (Collector)
photo_R_4: J1.14, R31.2, U15.4 (Collector)
photo_R_5: J1.15, R32.2, U16.4 (Collector)
photo_R_6: J1.16, R33.2, U17.4 (Collector)
photo_R_7: J1.17, R34.2, U18.4 (Collector)
photo_center: J1.9, R17.2, U9.4 (Collector)
photo_front: J1.10, R18.2, U10.4 (Collector)

File 1-TOKYO/04-line/jlcpcb/production_files/BOM-04-line.csv:

Comment,Designator,Footprint,LCSC
100n,"C3,C6",C_0402_1005Metric,C1525
1k,"R10,R11,R12,R13,R14,R15,R16,R17,R18,R28,R29,R30,R31,R32,R33,R34",R_0603_1608Metric,C21190
120,"R1,R19,R2,R20,R21,R22,R23,R24,R25,R3,R4,R5,R6,R7,R8,R9",R_0603_1608Metric,C22787
WS2812B,"D1,D2,D4,D5,D6,D8",LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,C2843785
Conn_01x18,J1,PinHeader_1x18_P2.54mm_Vertical,
CS_L,J3,PinHeader_2x03_P2.54mm_Vertical,
~,U2,LBR127HLD,
~,U15,LBR127HLD,
~,U14,LBR127HLD,
~,U25,S11059,
~,U7,LBR127HLD,
~,U4,LBR127HLD,
~,U5,LBR127HLD,
~,U16,LBR127HLD,
~,U17,LBR127HLD,
~,U8,LBR127HLD,
~,U12,LBR127HLD,
~,U3,LBR127HLD,
~,U26,S11059,
~,U9,LBR127HLD,
~,U18,LBR127HLD,
~,U6,LBR127HLD,
~,U10,LBR127HLD,
~,U13,LBR127HLD,
CS_R,J2,PinHeader_2x03_P2.54mm_Vertical,

## KiCad design 1-TOKYO/06_WRITER/06_WRITER.kicad_pcb

Parts:
C1, C2: 100n; C_0805_2012Metric; LCSC C49678
D1: LED_GREEN; LED_1206_3216Metric; LCSC C499475
D2: LED_ORANGE; LED_1206_3216Metric; LCSC C2764895
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal; LCSC C19274016
J2: Conn_02x04_Counter_Clockwise; PinHeader_2x04_P2.54mm_Vertical
R1, R2: 5.1k; R_0805_2012Metric; LCSC C27834
R3, R4: 75; R_0805_2012Metric; LCSC C441974
SW1: NRST; SW_PUSH_6mm
SW2: BOOT0; SW_PUSH_6mm
U1: CH340E; MSOP-10_3x3mm_P0.5mm; LCSC C99652

Connections:
+3V3: J2.8, SW2.1
+5V: C1.1, D1.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U1.7 (VCC)
BOOT0: J2.5, SW2.2
D+: J1.A6 (D+), J1.B6 (D+), U1.1 (UD+)
D-: J1.A7 (D-), J1.B7 (D-), U1.2 (UD-)
GND: C1.2, C2.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.6, R1.1, R2.1, R3.2, R4.2, SW1.1, U1.3 (GND)
NRST: J2.3, SW1.2
unnamed: D1.1 (K), R3.1
unnamed: D2.2 (A), U1.6 (TNOW)
unnamed: D2.1 (K), R4.1
unnamed: J1.A5 (CC1), R1.2
unnamed: J1.B5 (CC2), R2.2
unnamed: C2.2, U1.10 (V3)
RX: J2.2, U1.8 (TXD)
TX: J2.4, U1.9 (RXD)

Notes on the sheet:
RX NRST TX BOOT GND 3V3

Board: 2 copper layers, 22.9 x 39.4 mm, 13 parts (0 on the bottom side), 15 nets.
